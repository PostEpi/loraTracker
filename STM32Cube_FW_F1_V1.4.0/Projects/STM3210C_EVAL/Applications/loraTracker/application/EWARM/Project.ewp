# IAR project Project.ewp, settings and files
configuration STM3210C_LoraTracker (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105VC ST STM32F105VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F105xC; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM3210C_LoraTracker; ..\..\..\..\..\..\Middlewares\Third_Party\utilities; ..\..\..\..\..\..\Middlewares\ST\flash; ..\..\..\..\..\..\Middlewares\Third_Party\easyflash\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f107xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application/EWARM
    ./: startup_stm32f107xc.s
  group application/User
    ../Src/: bbox.c circledistance.c debuglog.c demd.c ecom.c ecommand.c gcom.c gcommand.c iotgps.c lcom.c lcommand.c main.c nmea.c rqueue.c rtc.c stm32f1xx_hal_msp.c stm32f1xx_it.c timtimer.c tiny_vsnprintf.c vdb.c wisol.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM3210C_LoraTracker
    ../../../../../../Drivers/BSP/STM3210C_LoraTracker/: stm3210c_loraTracker.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/ST/flash
    ../../../../../../Middlewares/ST/flash/: flash_if.c
  group Middlewares/Third_Party/easyflash/port
    ../../../../../../Middlewares/Third_Party/easyflash/port/: ef_port.c
  group Middlewares/Third_Party/easyflash/src
    ../../../../../../Middlewares/Third_Party/easyflash/src/: easyflash.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
  group Middlewares/Third_Party/utilities
    ../../../../../../Middlewares/Third_Party/utilities/: timeServer.c timeServer.h utilities.c utilities.h
